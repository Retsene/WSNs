<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MOI_TRUONG.ewp</path>
  </project>
  <batchBuild />
</workspace>
